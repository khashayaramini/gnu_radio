options:
  parameters:
    author: raven
    generate_options: qt_gui
    id: tempest_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '50000000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '250000'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/raven/stdout
    type: short
    unbuffered: 'True'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '-1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-500'
    type: float
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '50'
    bw0: '10'
    freq0: '396026900'
    gain0: '50'
    gain_mode0: 'False'
    if_gain0: '50'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: tempest_fine_sampling_synchronization_0
  id: tempest_fine_sampling_synchronization
  parameters:
    Htotal: '1920'
    Vtotal: '1080'
    correct_sampling: '1'
    max_deviation: '16e-3'
    update_proba: '9e-9'
  states: {}
- name: tempest_normalize_flow_0
  id: tempest_normalize_flow
  parameters:
    alpha_avg: '0.01'
    max: '250'
    min: '10'
    update_proba: '0.1'
    window: '1080'
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_delay_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_float_to_short_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', tempest_normalize_flow_0, '0']
- [osmosdr_source_0, '0', tempest_fine_sampling_synchronization_0, '0']
- [tempest_fine_sampling_synchronization_0, '0', blocks_delay_0, '0']
- [tempest_normalize_flow_0, '0', blocks_float_to_short_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
