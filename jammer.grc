options:
  parameters:
    author: raven
    generate_options: qt_gui
    id: binary_source_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    maxFreqHz: 6e9
    minFreqHz: 30e6
    value: 2.4e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '100'
    noise_type: analog.GR_UNIFORM
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 15e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '50'
    bw0: 20e6
    freq0: freq
    gain0: '50'
    if_gain0: '50'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    key: value
    label: freq
    type: float
    value: 2.4e9
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', osmosdr_sink_0, '0']
- [analog_noise_source_x_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_sig_source_x_0, '0', blocks_null_sink_0, '0']
- [qtgui_edit_box_msg_0, msg, freq, valuein]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
