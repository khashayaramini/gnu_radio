options:
  parameters:
    author: raven
    generate_options: qt_gui
    id: file_source
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/raven/Desktop/file_test
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_ofdm_tx_0_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=1"'
    bb_gain0: '30'
    freq0: 200e6
    gain0: '30'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Rx Spectrum
    name: Rx Spectrum
    showports: 'True'
    type: complex
  states: {}

connections:
- [blocks_file_source_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_ofdm_tx_0_0, '0']
- [blocks_throttle2_0, '0', osmosdr_sink_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_ofdm_tx_0_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
